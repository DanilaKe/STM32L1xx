# IAR project 04.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xC ST STM32L152xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L1XX_MDP; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: D:\Work\stm32\prj04\STM32L1xx_StdPeriph_Driver\src; D:\Work\stm32\prj04\STM32L1xx_StdPeriph_Driver\inc; D:\Work\stm32\prj04\inc; D:\Work\stm32\prj04
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group inc
    inc/: onewire.c onewire.h startup_stm32l1xx_mdp.s stm32l1xx.h stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h system_stm32l1xx.c system_stm32l1xx.h
  group scr
    STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group user
    ./: main.cpp
    ../../C/: main.ENU.projtempl
